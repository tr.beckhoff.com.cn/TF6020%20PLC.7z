TYPE ST_Cylinder_HMI :
STRUCT
	Status:ST_Cylinder_Status;
	Command:ST_Cylinder_Command;
END_STRUCT
END_TYPE
