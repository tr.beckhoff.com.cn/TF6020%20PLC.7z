TYPE ST_Product :
STRUCT
	Code:STRING;
	Temperature:REAL;
	Pressure:REAL;
	Data:ARRAY[0..9] OF INT;
END_STRUCT
END_TYPE
