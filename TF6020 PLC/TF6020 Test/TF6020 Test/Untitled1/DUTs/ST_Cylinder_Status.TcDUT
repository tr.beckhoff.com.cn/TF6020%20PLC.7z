TYPE ST_Cylinder_Status :
STRUCT
	Status1:BOOL;
	Status2:BOOL;
END_STRUCT
END_TYPE
