TYPE ST_Cylinder_Command :
STRUCT
	Command1:BOOL;
	Command2:BOOL;
END_STRUCT
END_TYPE
