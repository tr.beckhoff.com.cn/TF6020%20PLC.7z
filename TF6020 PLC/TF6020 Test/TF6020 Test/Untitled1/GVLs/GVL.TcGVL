{attribute 'qualified_only'}
VAR_GLOBAL
	Product:ST_Product;
	Cylinder1:ST_Cylinder_HMI;
	CylinderArray:ARRAY[0..9] OF ST_Cylinder_HMI;
	 
END_VAR
